DESCRIPTION = "Joske 13E,19E"

PN = "enigma2-plugin-settings-joske-13e-19e"

SETTINGS_FILENAME = "joskea-hdream"

include joske.inc