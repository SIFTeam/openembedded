DESCRIPTION = "Henksat Alatas 7E,13E,19E,23E,28E,42E"

PN = "enigma2-plugin-settings-henksat-7e-13e-19e-23e-28e-42e"

SETTINGS_FILENAME = "henksat_alatas_astra_1_2_3_hb_42e_7e_e2"

include henksat.inc
