DESCRIPTION = "Hans 13E,19E,23E,28E and rotating"

PN = "enigma2-plugin-settings-hans-13e-19e-23e-28e-rotating"

SETTINGS_FILENAME = "hans_13e_19e_23e_28e_and_rotating_e2"

include hans.inc
