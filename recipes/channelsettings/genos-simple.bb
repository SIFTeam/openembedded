DESCRIPTION = "genoSUAVE DishPRO simple"

PN = "enigma2-plugin-settings-genos-simple"

SETTINGS_FILENAME = "genos_simple_dp"

include genos.inc
