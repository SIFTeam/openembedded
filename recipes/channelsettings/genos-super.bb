DESCRIPTION = "genoSUAVE DishPRO super"

PN = "enigma2-plugin-settings-genos-super"

SETTINGS_FILENAME = "genos_super-service_dp"

include genos.inc
