DESCRIPTION = "Henksat 13E,19E"

PN = "enigma2-plugin-settings-henksat-13e-19e"

SETTINGS_FILENAME = "henksat_astra_1_hb_e2"

include henksat.inc
