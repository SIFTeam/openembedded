DESCRIPTION = "Henksat 19E,23E,28E"

PN = "enigma2-plugin-settings-henksat-19e-23e-28e"

SETTINGS_FILENAME = "henksat_full_astra_1_2_3_e2"

include henksat.inc
