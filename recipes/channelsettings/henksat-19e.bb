DESCRIPTION = "Henksat 19E"

PN = "enigma2-plugin-settings-henksat-19e"

SETTINGS_FILENAME = "henksat_astra_1_e2"

include henksat.inc
