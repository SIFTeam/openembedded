DESCRIPTION = "PET123 13E,19E,28E"

PN = "enigma2-plugin-settings-pet123-13e-19e-28e"

SETTINGS_FILENAME = "pet123_191328"

include pet123.inc
