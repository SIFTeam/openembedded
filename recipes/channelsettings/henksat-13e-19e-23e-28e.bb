DESCRIPTION = "Henksat 13E,19E,23E,28E"

PN = "enigma2-plugin-settings-henksat-13e-19e-23e-28e"

SETTINGS_FILENAME = "henksat_astra_1_2_3_hb_e2"

include henksat.inc
