DESCRIPTION = "Hans 13E,19E,23E,28E"

PN = "enigma2-plugin-settings-hans-13e-19e-23e-28e"

SETTINGS_FILENAME = "hans_13e_19e_23e_28e_e2"

include hans.inc
