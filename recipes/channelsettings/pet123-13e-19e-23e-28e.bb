DESCRIPTION = "PET123 13E,19E,23E,28E"

PN = "enigma2-plugin-settings-pet123-13e-19e-23e-28e"

SETTINGS_FILENAME = "pet123_19132823"

include pet123.inc
