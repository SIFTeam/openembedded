require rytec-settings13e19e23e28e.bb
SRC_URI = "http://www.rytec.be/tools/Rytec_E2_Motor_${SRCDATE}.zip"
SATNAMES = "motor"
S="${WORKDIR}/Rytec_E2_Motor_${SRCDATE}"
