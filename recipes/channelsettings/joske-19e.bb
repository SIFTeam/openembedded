DESCRIPTION = "Joske 19E"

PN = "enigma2-plugin-settings-joske-19e"

SETTINGS_FILENAME = "joskeastradream"

include joske.inc
