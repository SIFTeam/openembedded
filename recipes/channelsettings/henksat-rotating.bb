DESCRIPTION = "Henksat Rotating (45.0e-45.0w)"

PN = "enigma2-plugin-settings-henksat-rotating"

SETTINGS_FILENAME = "henksat_rotating_45e_45w_e2"

include henksat.inc
