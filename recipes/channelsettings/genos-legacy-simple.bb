DESCRIPTION = "genoSUAVE Legacy simple"

PN = "enigma2-plugin-settings-genos-simple-legacy"

SETTINGS_FILENAME = "genos_simple_legacy"

include genos.inc
