DESCRIPTION = "Joske 13E,19E,23E,28E"

PN = "enigma2-plugin-settings-joske-13e-19e-23e-28e"

SETTINGS_FILENAME = "joskeastra123hbdream"

include joske.inc
