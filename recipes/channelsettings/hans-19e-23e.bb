DESCRIPTION = "Hans 19E,23E"

PN = "enigma2-plugin-settings-hans-19e-23e"

SETTINGS_FILENAME = "hans_19e_23e_e2"

include hans.inc
