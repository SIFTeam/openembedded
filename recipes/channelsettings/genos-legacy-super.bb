DESCRIPTION = "genoSUAVE Legacy super"

PN = "enigma2-plugin-settings-genos-super-legacy"

SETTINGS_FILENAME = "genos_super-service_legacy"

include genos.inc
