DESCRIPTION = "Joske rotating"

PN = "enigma2-plugin-settings-joske-rotating"

SETTINGS_FILENAME = "joskedraaibaardream"

include joske.inc
