DESCRIPTION = "Henksat 13E,19E,23E,28E,4.8E,0.8W"

PN = "enigma2-plugin-settings-henksat-13e-19e-23e-28e-4.8e-0.8w"

SETTINGS_FILENAME = "henksat_astra_1_2_3_hb_sirius_thor_e2"

include henksat.inc
