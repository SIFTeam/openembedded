DESCRIPTION = "PET123 19E"

PN = "enigma2-plugin-settings-pet123-19e"

SETTINGS_FILENAME = "pet123_19"

include pet123.inc
