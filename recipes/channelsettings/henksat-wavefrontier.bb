DESCRIPTION = "Henksat Wavefrontier"

PN = "enigma2-plugin-settings-henksat-wavefrontier"

SETTINGS_FILENAME = "henksat_wavefrontier_e2"

include henksat.inc
