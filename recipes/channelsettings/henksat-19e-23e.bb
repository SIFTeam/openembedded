DESCRIPTION = "Henksat 19E,23E"

PN = "enigma2-plugin-settings-henksat-19e-23e"

SETTINGS_FILENAME = "henksat_astra_1_3_e2"

include henksat.inc
