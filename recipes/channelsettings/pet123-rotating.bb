DESCRIPTION = "PET123 rotating"

PN = "enigma2-plugin-settings-pet123-rotating"

SETTINGS_FILENAME = "pet123dreamsettings"

include pet123.inc
