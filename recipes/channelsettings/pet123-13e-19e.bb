DESCRIPTION = "PET123 13E,19E"

PN = "enigma2-plugin-settings-pet123-13e-19e"

SETTINGS_FILENAME = "pet123_1913"

include pet123.inc
