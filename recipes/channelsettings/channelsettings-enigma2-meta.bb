DESCRIPTION = "meta file for settings"

DEPENDS = "\
	enigma2-plugin-settings-henksat-19e \
	enigma2-plugin-settings-henksat-13e-19e \
	enigma2-plugin-settings-henksat-19e-23e \
	enigma2-plugin-settings-henksat-19e-23e-28e \
	enigma2-plugin-settings-henksat-13e-19e-23e-28e \
	enigma2-plugin-settings-henksat-wavefrontier \
	enigma2-plugin-settings-henksat-rotating \
	enigma2-plugin-settings-henksat-7e-13e-19e-23e-28e-42e \
	enigma2-plugin-settings-pet123-19e \
	enigma2-plugin-settings-pet123-13e-19e \
	enigma2-plugin-settings-pet123-13e-19e-28e \
	enigma2-plugin-settings-pet123-13e-19e-23e-28e \
	enigma2-plugin-settings-pet123-rotating \
	enigma2-plugin-settings-joske-19e \
	enigma2-plugin-settings-joske-13e-19e \
	enigma2-plugin-settings-joske-13e-19e-23e-28e \
	enigma2-plugin-settings-joske-rotating \
	enigma2-plugin-settings-genos-simple \
	enigma2-plugin-settings-genos-super \
	enigma2-plugin-settings-genos-simple-legacy \
	enigma2-plugin-settings-genos-super-legacy \
	enigma2-plugin-settings-rytec-13e19e23e28e \
	enigma2-plugin-settings-rytec-motor \
	"

PR = "r0"
