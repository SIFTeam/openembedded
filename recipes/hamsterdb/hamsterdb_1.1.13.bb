DESCRIPTION = "lightweight embedded NoSQL key-value store"
LICENSE = "GPLv2 and others"

SRC_URI = "http://hamsterdb.com/dl/${PN}-${PV}.tar.gz"

inherit autotools
