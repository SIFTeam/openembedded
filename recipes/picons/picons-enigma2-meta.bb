# meta package for enigma2 picon sets

DEPENDS = " \
		enigma2-plugin-picons-sat \
		enigma2-plugin-picons-ziggo.tvhome \
		enigma2-plugin-picons-ziggo.casema \
		enigma2-plugin-picons-ziggo.casema.100x60 \
		"