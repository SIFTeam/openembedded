PICON_SATNAMES = "ziggo.tvhome"

PV = "${SRCDATE}"
PR = "r0"

SRC_URI = "http://downloads.pli-images.org/picons/picons-ziggo-tvhome-${SRCDATE}.tar.gz"

include enigma2-plugin-picons.inc
