require nzbget.inc
PR = "${INC_PR}.0"

SRC_URI[md5sum] = "27971846aba75f5e312d80dce7edbc5d"
SRC_URI[sha256sum] = "b798bbcc9f6816b4e19a95f74df067440f7ad49e1c16a3f33f99bddf7916771e"

