LICENSE = "LGPL"

SRC_URI = "http://linux.thai.net/pub/thailinux/software/libthai/libdatrie-${PV}.tar.gz"

inherit autotools

SRC_URI[md5sum] = "7f7d592114f98db9e4c7171c3f2befc5"
SRC_URI[sha256sum] = "b2acfbfd9df07780f91352bc1bb16e4d8a32772dc9194bbc35ae600e0591dfa2"

