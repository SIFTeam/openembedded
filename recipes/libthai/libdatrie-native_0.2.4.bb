require libdatrie_0.2.4.bb
inherit native

