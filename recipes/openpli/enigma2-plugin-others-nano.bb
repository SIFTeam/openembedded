DESCRIPTION = "Nano editor"
RDEPENDS_${PN} = "nano"

PN = "enigma2-plugin-others-nano"
PV = "1.3.9"
PR = "r1"

S = "${WORKDIR}"

ALLOW_EMPTY_${PN} = "1"
