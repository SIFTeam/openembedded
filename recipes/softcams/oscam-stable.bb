SRCREV = "3508"
ALTERNATIVE_PRIORITY = "20"
require oscam-bin.inc

