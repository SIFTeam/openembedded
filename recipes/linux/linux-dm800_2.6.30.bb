require linux-opendreambox.inc

SRCREV = "47f4aecc6036c7cb584aa4a4fffffe9c4dd453be"
PR = "r0"

