require linux-etx000_2.6.31.inc
