DESCRIPTION = "Linux kernel for et5000"

require linux-etx000.inc
