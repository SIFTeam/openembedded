DESCRIPTION = "Linux kernel for et5000"

require linux-etx000_2.6.31.inc
