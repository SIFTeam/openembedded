require linux-opendreambox.inc

SRCREV = "b8af0742b4088732b69a9212606ccf25ae8aae77"
PR = "r0"

