require linux-opendreambox.inc

SRCREV = "c87352cc70aac236942fde213a710ac0e06073ec"
PR = "r0"

