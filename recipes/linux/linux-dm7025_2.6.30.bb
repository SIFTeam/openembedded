require linux-opendreambox.inc

SRCREV = "049307546c6b142fe90808206373dd38d87da010"
PR = "r1"

