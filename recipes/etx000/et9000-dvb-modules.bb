DESCRIPTION = "Hardware drivers for et9000"

SRCDATE = "20110811"

include et-dvb-modules.inc
