require minidlna_1.0.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "be9b4c91e3fcde592dc3f9828098ca0f"
SRC_URI[sha256sum] = "840ac2303c23d63066912750391d1ebef7761b5b23493e590624a17670ceb942"
