require minidlna_1.0.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "3de2f6b54f43bb998dfad3c8fa75cef3"
SRC_URI[sha256sum] = "688919b23d5891d77045cd772e373314a83f002f79c9e754bcb7e521f3ba4349"
